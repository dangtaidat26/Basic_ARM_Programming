# Keil uVision project Blink_Two_LED.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: MKL46Z256VLL4 NXP
  pack: NXP.MKL46Z4_DFP.10.0.3
  cpu: IRAM(0x1fffe000,0x8000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Blink_Two_LED
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=.\Objects\Blink2LED.bin.\Objects\Blink2LED.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Source Group 1
    ./: main.c LED.c LED.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
