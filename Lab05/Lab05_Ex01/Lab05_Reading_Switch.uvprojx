# Keil uVision project Lab05_Reading_Switch.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL46Z256VLL4 NXP
  pack: NXP.MKL46Z4_DFP.10.0.3
  cpu: IRAM(0x1fffe000,0x8000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Lab05_Reading_Switch
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=.\Objects\Reading_Switch.bin.\Objects\Reading_Switch.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Source Group 1
    ./: Config_lab5.1.c Config_lab5.1.h main_lab5.1.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
