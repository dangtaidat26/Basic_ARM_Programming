# Keil uVision project LED_Blink_ASM_Delay.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL46Z256VLL4 NXP
  pack: NXP.MKL46Z4_DFP.10.0.3
  cpu: IRAM(0x1fffe000,0x8000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LED_Blink_ASM_Delay
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=.\Objects\ASM_Delay.bin .\Objects\ASM_Delay.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Source Group 1
    ./: main.c Delay.s Init.h Config.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
